# Keil uVision project STM32RF.uvprojx, settings and files
target STM32RF (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Source\STM32_FWLib\CMSIS;..\Source\STM32_FWLib\FWlib\inc;..\Source\Drivers;..\Source\Application\main;..\Source\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Source/STM32_FWLib/CMSIS/startup/: startup_stm32f10x_hd.s
  group Application
    ../Source/Application/main/: main.c stm32f10x_it.c rf.c function.c
  group Drivers
    ../Source/Drivers/: oled.c usart1.c I2C.c SI7021.c Delay.c sx1276-LoRaMisc.c SPI.c gpio.c sx1276-LoRa.c timeget.c
  group FWlib
    ../Source/STM32_FWLib/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Source/STM32_FWLib/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c
software components: CMSIS:CORE 4.3.0
